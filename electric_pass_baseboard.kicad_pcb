# Repository inapp123/epass_hardware

File README.md:

# 明日方舟电子通行认证 PCB

一款类似手机游戏《明日方舟》中的通行认证的电子挂牌。

当前版本：Ver0.6

本项目存放通行认证的PCB电路设计。PCB为群友“你说得对”使用嘉立创EDA进行Layout。

USB布线比我的kicad好，而且只需要二层板。如果你需要查看原始kicad设计文件，请在左上角将分支切换为：onlykicad。

设计。工艺参数参考嘉立创二层板，设计厚度为1mm。

## 文件

* 阻容封装0402：
  * ProDoc__v0.6_0402_2026-01-24.epro2 PCB设计文件
  * InteractiveBOM_0.6_0402_2026-1-24.html 交互式BOM

* 阻容封装0603：
  * ProDoc__v0.6_0603_2026-01-24.epro2 PCB设计文件
  * InteractiveBOM_0.6_0603_2026-1-24.html 交互式BOM

**最新嘉立创专业版打开，不知道什么意思就打0603**

## BOM链接

感谢 星语Studio 整理！

0603版本：https://docs.qq.com/sheet/DTUNVSW9USXBOS3VJ?nlc=1&tab=8444d8
0402版本：https://docs.qq.com/sheet/DTUNVSW9USXBOS3VJ?nlc=1&tab=msd95g

## 开源协议

CERN Open Hardware Licence Version 2 - Permissive

## KiCad design electric_pass_baseboard.kicad_pcb

Parts:
C38: 10uF; C_0603_1608Metric
D7, D8: ESD5Z3V3; D_SOD-523
FID1, FID2, FID3, FID4: Fiducial; Fiducial_1mm_Mask3mm
J1: USB_C_Receptacle_USB2.0_16P; USB_C_Receptacle_HCTL_HC-TYPE-C-16P-01A
J2, J3: Conn_02x05_Counter_Clockwise; HDR-SMD_10P-P2.54-H-F-R2-C5-W8.5
R1, R2: 5.1K; R_0603_1608Metric
R40: 10R; R_0603_1608Metric
R43, R45: 2K; R_0603_1608Metric
TP4, TP5, TP7, TP8, TP9, TP10: TestPoint; TestPoint_Pad_D1.0mm
U7: PW1515; SOT-23-5

Connections:
+3.3V: J3.5; also elsewhere on the board
/ADC: J3.8; also elsewhere on the board
/PE3: J2.6; also elsewhere on the board
/PE5: J2.2; also elsewhere on the board
/PE6: J2.9; also elsewhere on the board
/SPI1_CS: J2.3; also elsewhere on the board
/SPI1_MISO: J2.7; also elsewhere on the board
/SPI1_MOSI: J2.8; also elsewhere on the board
/SPI1_SCK: J2.4; also elsewhere on the board
/TVIN0: J3.3; also elsewhere on the board
/TVOUT: J3.4; also elsewhere on the board
/TWI0_SCL: J3.10; also elsewhere on the board
/TWI0_SDA: J3.2; also elsewhere on the board
/UART0_RX: J2.1; also elsewhere on the board
/UART0_TX: J2.10; also elsewhere on the board
/UART1_RX: J3.7; also elsewhere on the board
/UART1_TX: J3.6; also elsewhere on the board
/USB_DN: D8.1 (K), J1.A7 (D-), J1.B7 (D-); also elsewhere on the board
/USB_DP: D7.1 (K), J1.A6 (D+), J1.B6 (D+); also elsewhere on the board
/VBAT_SENSE: J3.9, R40.1; also elsewhere on the board
/VBUS_IN: J1.A4 (VBUS), J1.A9 (VBUS), J1.B4 (VBUS), J1.B9 (VBUS), U7.5 (VIN)
/adc_periph/ADCBAT: R40.2; also elsewhere on the board
/screen/SCREEN_CS: TP4.1; also elsewhere on the board
/screen/SCREEN_HS: TP10.1; also elsewhere on the board
/screen/SCREEN_PCLK: TP8.1; also elsewhere on the board
/screen/SCREEN_SCL: TP7.1; also elsewhere on the board
/screen/SCREEN_SDA: TP5.1; also elsewhere on the board
/screen/SCREEN_VS: TP9.1; also elsewhere on the board
GND: C38.2, D7.2 (A), D8.2 (A), J1.A1 (GND), J1.A12 (GND), J1.B1 (GND), J1.B12 (GND), J1.S1 (SHIELD), J3.1, R1.2, R2.2, R43.1, R45.1, U7.2 (GND); also elsewhere on the board
unnamed: J1.A5 (CC1), R1.1
unnamed: J1.B5 (CC2), R2.1
unnamed: R43.2, R45.2, U7.3 (IADJ)
VBAT_OUT: J2.5; also elsewhere on the board
VBUS: C38.1, U7.1 (VOUT); also elsewhere on the board

Notes on the sheet:
过压/过流保护 我麻了啊，怎么快冲还会误触发的 感谢：西南季风大哥！ I_OCP = 600/1000 = 0.6A
*1：ADC1用于电池采样功能选择 若拆焊R40 ，则ADC可用于外部IO，但会失去电池电量检测功能
特别感谢：（不分先后）和光、薄云、烟雨、WXNA、西南季风、“你说得对” 土豆、星语Studio、爱莉希雅、所有复刻群友的支持！

Parts:
C46: 100nF; C_0603_1608Metric
R3, R33, R34, R38, R39, R44: 10K; R_0603_1608Metric
R31: 68K; R_0603_1608Metric
SW2, SW4, SW5, SW6: TS24CA; SW-SMD_TS24CA; LCSC Part C393942

Connections:
+3.3V: R31.2; also elsewhere on the board
/PWR_BTN: R3.2, R31.1; also elsewhere on the board
/adc_periph/ADCBAT: C46.1, R38.1, R39.2; also elsewhere on the board
GND: C46.2, R39.1, SW2.1, SW2.2, SW2.3, SW4.1, SW4.2, SW4.3, SW5.1, SW5.2, SW5.3, SW6.1, SW6.2, SW6.3; also elsewhere on the board
unnamed: R3.1, R33.2, SW4.4
unnamed: R33.1, R34.2, SW5.4
unnamed: R34.1, R44.2, SW6.4
unnamed: R44.1, SW2.4
VBAT_OUT: R38.2; also elsewhere on the board

Notes on the sheet:
ADC记得加电容哦 否则可能采样波动大 感谢和光老师
AllWinner KeyADC: Voltage:0~3V 6-bit
AllWinner GPADC(TP): Voltage:0~3V 12 bit

Parts:
C13, C15, C16, C40, C41, C42, C43, C44, C49, C50: 1uF; C_0603_1608Metric
C14, C17, C18, C19, C20, C21, C22, C23, C24, C25, C26, C27, C28, C30: 100nF; C_0603_1608Metric
C29, C31: 22pF; C_0603_1608Metric
R22, R23: 5.1K; R_0603_1608Metric
R24: 10K; R_0603_1608Metric
R25, R26: 2K; R_0603_1608Metric
R37, R63: 200K; R_0603_1608Metric
U3: F1C200S; QFN-88_L10.0-W10.0-P0.40-BL-EP6.75; LCSC Part C1511928
Y1: 24Mhz 12pF; Crystal_SMD_3225-4Pin_3.2x2.5mm

Connections:
+1V2: C21.1, C23.1, C28.1, U3.22 (VDD-CORE), U3.35 (VDD-CORE), U3.71 (VDD-CORE); also elsewhere on the board
+2V5: C14.1, C17.1, C18.1, C22.1, C24.1, C26.1, R25.2, U3.30 (VCC-DRAM), U3.31 (VCC-DRAM), U3.32 (VCC-DRAM), U3.34 (VCC-DRAM), U3.36 (VCC-DRAM), U3.80 (AVCC); also elsewhere on the board
+3.3V: C19.1, C20.1, C25.1, C27.1, R22.2, R23.2, R24.2, U3.4 (HPVCC), U3.5 (VCC-IO), U3.20 (VCC-IO), U3.50 (VCC-IO), U3.67 (UVCC), U3.73 (TV_VCC); also elsewhere on the board
/ADC: U3.65 (TPX2); also elsewhere on the board
/PE3: U3.46 (PE3); also elsewhere on the board
/PE5: U3.44 (PE5); also elsewhere on the board
/PE6: U3.43 (PE6); also elsewhere on the board
/PWR_BTN: U3.79 (LRADC0); also elsewhere on the board
/SPI1_CS: U3.42 (PE7); also elsewhere on the board
/SPI1_MISO: U3.39 (PE10); also elsewhere on the board
/SPI1_MOSI: U3.41 (PE8); also elsewhere on the board
/SPI1_SCK: U3.40 (PE9); also elsewhere on the board
/TVIN0: U3.78 (TVIN0); also elsewhere on the board
/TVOUT: U3.72 (TVOUT); also elsewhere on the board
/TWI0_SCL: R22.1, U3.18 (PD12); also elsewhere on the board
/TWI0_SDA: R23.1, U3.6 (PD0); also elsewhere on the board
/UART0_RX: U3.49 (PE0); also elsewhere on the board
/UART0_TX: U3.48 (PE1); also elsewhere on the board
/UART1_RX: U3.64 (TPY1); also elsewhere on the board
/UART1_TX: U3.63 (TPY2); also elsewhere on the board
/USB_DN: U3.68 (USB_DM); also elsewhere on the board
/USB_DP: U3.69 (USB_DP); also elsewhere on the board
/VBAT_SENSE: U3.66 (TPX1); also elsewhere on the board
/power/PWR_SHUTDOWN: U3.47 (PE2); also elsewhere on the board
/screen/SCREEN_B0: U3.19 (PD13); also elsewhere on the board
/screen/SCREEN_B1: U3.21 (PD14); also elsewhere on the board
/screen/SCREEN_B2: U3.23 (PD15); also elsewhere on the board
/screen/SCREEN_B3: U3.24 (PD16); also elsewhere on the board
/screen/SCREEN_B4: U3.25 (PD17); also elsewhere on the board
/screen/SCREEN_BL_CTRL: U3.37 (PE12); also elsewhere on the board
/screen/SCREEN_CS: U3.38 (PE11); also elsewhere on the board
/screen/SCREEN_G0: U3.12 (PD6); also elsewhere on the board
/screen/SCREEN_G1: U3.13 (PD7); also elsewhere on the board
/screen/SCREEN_G2: U3.14 (PD8); also elsewhere on the board
/screen/SCREEN_G3: U3.15 (PD9); also elsewhere on the board
/screen/SCREEN_G4: U3.16 (PD10); also elsewhere on the board
/screen/SCREEN_G5: U3.17 (PD11); also elsewhere on the board
/screen/SCREEN_HS: U3.28 (PD20); also elsewhere on the board
/screen/SCREEN_PCLK: U3.26 (PD18); also elsewhere on the board
/screen/SCREEN_R0: U3.7 (PD1); also elsewhere on the board
/screen/SCREEN_R1: U3.8 (PD2); also elsewhere on the board
/screen/SCREEN_R2: U3.9 (PD3); also elsewhere on the board
/screen/SCREEN_R3: U3.10 (PD4); also elsewhere on the board
/screen/SCREEN_R4: U3.11 (PD5); also elsewhere on the board
/screen/SCREEN_SCL: U3.27 (PD19); also elsewhere on the board
/screen/SCREEN_SDA: U3.45 (PE4); also elsewhere on the board
/screen/SCREEN_VS: U3.29 (PD21); also elsewhere on the board
/soc_f1c/F1C_RST: C30.1, R24.1, U3.70 (RESET)
/soc_f1c/NAND_CS: U3.60 (PC1); also elsewhere on the board
/soc_f1c/NAND_MISO: U3.61 (PC2); also elsewhere on the board
/soc_f1c/NAND_MOSI: U3.62 (PC3); also elsewhere on the board
/soc_f1c/OSC_IN1: C29.1, U3.52 (HOSCO), Y1.1
/soc_f1c/OSC_IN2: C31.1, U3.51 (HOSCI), Y1.3
/soc_f1c/SDIO_CLK: U3.56 (PF2); also elsewhere on the board
/soc_f1c/SDIO_CMD: U3.55 (PF3); also elsewhere on the board
/soc_f1c/SDIO_D0: U3.57 (PF1); also elsewhere on the board
/soc_f1c/SDIO_D1: U3.58 (PF0); also elsewhere on the board
/soc_f1c/SDIO_D2: U3.53 (PF5); also elsewhere on the board
/soc_f1c/SDIO_D3: U3.54 (PF4); also elsewhere on the board
/soc_f1c/SVREF: R25.1, R26.2, U3.33 (SVREF)
/soc_f1c/TV_VRA1: C13.1, C15.1, U3.75 (TV_VRN)
/soc_f1c/TV_VRA2: C15.2, C16.1, U3.76 (TV_VRP)
/soc_f1c/VRA1: C49.1, R37.2, U3.81 (VRA1)
/soc_f1c/VRA2: C50.1, R63.2, U3.83 (VRA2)
/soc_peripherals/NAND_CLK: U3.59 (PC0); also elsewhere on the board
GND: C13.2, C14.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, C23.2, C24.2, C25.2, C26.2, C27.2, C28.2, C29.2, C30.2, C31.2, C40.1, C41.1, C42.1, C43.1, C44.1, C49.2, C50.2, R26.1, R37.1, R63.1, U3.74 (TVGND), U3.82 (AGND), U3.89 (GND), Y1.2, Y1.4; also elsewhere on the board
unnamed: C44.2, U3.84 (FMINL)
unnamed: C43.2, U3.85 (FMINR)
unnamed: C40.2, U3.2 (HPCOMFB)
unnamed: C42.2, U3.86 (LINL)
unnamed: C41.2, U3.87 (MICIN)

Parts:
C37, C45: 100nF; C_0603_1608Metric
Card1: TF-115-BCP9; TF-SMD_TF-115-BCP9; LCSC Part C720505
R5, R6, R8, R35, R36: 10K; R_0603_1608Metric
SW9: TS24CA; SW-SMD_TS24CA; LCSC Part C393942
U6: W25N01GVZEIG_C907680; WSON-8_L8.0-W6.10-P1.27-BL-EP; LCSC Part C907680

Connections:
+3.3V: C37.1, C45.2, Card1.4 (VDD), R5.2, R6.2, R8.2, R35.2, R36.2, U6.3 (WP#(DQ2)), U6.7 (HOLD#(DQ3)), U6.8 (VCC); also elsewhere on the board
/soc_f1c/NAND_CS: U6.1 (~CS); also elsewhere on the board
/soc_f1c/NAND_MISO: U6.2 (DO(DQ1)); also elsewhere on the board
/soc_f1c/NAND_MOSI: U6.5 (DI(DQ0)); also elsewhere on the board
/soc_f1c/SDIO_CLK: Card1.5 (CLK); also elsewhere on the board
/soc_f1c/SDIO_CMD: Card1.3 (CMD), R8.1; also elsewhere on the board
/soc_f1c/SDIO_D0: Card1.7 (DAT0), R6.1; also elsewhere on the board
/soc_f1c/SDIO_D1: Card1.8 (DAT1), R5.1; also elsewhere on the board
/soc_f1c/SDIO_D2: Card1.1 (DATA2), R36.1; also elsewhere on the board
/soc_f1c/SDIO_D3: Card1.2 (CD/DATA3), R35.1; also elsewhere on the board
/soc_peripherals/NAND_CLK: SW9.4, U6.6 (CLK); also elsewhere on the board
GND: C37.2, C45.1, Card1.6 (VSS), Card1.10 (GND), Card1.11 (GND), Card1.12 (GND), Card1.13 (GND), SW9.1, SW9.2, SW9.3, U6.4 (VSS), U6.9 (EP); also elsewhere on the board

Notes on the sheet:
Force FEL Button

Parts:
C1, C2, C3, C4, C5, C9, C11, C12, C48: 10uF; C_0603_1608Metric
C6: 1uF; C_0603_1608Metric
C7, C8, C10: 220pF; C_0603_1608Metric
C47: 100nF; C_0603_1608Metric
D1, D3, D4: LED; LED_0805_2012Metric
D2, D6: 1N5819WS; D_SOD-323
H1, H2, H3, H4: MountingHole_Pad; MountingHole_2.7mm_M2.5_DIN965_Pad
L1, L2, L3: FTC252012S1R5MBCA; IND-SMD_L2.5-W2.0-VLS252012CX-150M
Q1, Q2: AO3401A; SOT-23
R4, R14, R18, R19, R32: 10K; R_0603_1608Metric
R9: 0.2R; R_0805_2012Metric
R10: 2K; R_0603_1608Metric
R11, R15, R16, R17, R20: 68K; R_0603_1608Metric
R12, R13: 5.1K; R_0603_1608Metric
R21: 15K; R_0603_1608Metric
SW1: TS24CA; SW-SMD_TS24CA; LCSC Part C393942
TP1, TP2, TP3, TP6, TP11, TP12: TestPoint; TestPoint_Pad_D1.0mm
U1: TP4056-42-ESOP8; SOIC-8-1EP_3.9x4.9mm_P1.27mm_EP2.41x3.3mm_ThermalVias
U2: EA3036C; WQFN-20_L3.0-W3.0-P0.40-BL-EP; LCSC Part C570857
U8: GEK100-XX; SOT-23-6
U10: ZX-SH1.0-2PWT; CONN-SMD_2P-P1.00_HX-1.0-2P-WT; LCSC Part C7430444

Connections:
+1V2: C7.1, C9.1, L1.2, R15.1, TP1.1; also elsewhere on the board
+2V5: C8.1, C11.1, L2.2, R17.2, TP2.1; also elsewhere on the board
+3.3V: C10.1, C12.1, L3.2, R12.1, R20.2, TP3.1; also elsewhere on the board
/PWR_BTN: D6.2 (A); also elsewhere on the board
/power/PWR_SHUTDOWN: U8.3 (RST); also elsewhere on the board
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C9.2, C11.2, C12.2, C47.2, C48.2, D4.1 (K), H1.1, H2.1, H3.1, H4.1, R11.1, R13.2, R14.1, R16.1, R19.1, R21.1, SW1.1, SW1.2, SW1.3, TP6.1, U1.1 (TEMP), U1.3 (GND), U1.9 (EPAD), U2.1 (GND3), U2.4 (GND2), U2.5 (GND2), U2.12 (GND1), U2.13 (GND1), U2.15 (AGND), U2.17 (AGND), U2.21 (PAD), U8.2 (GND), U10.2, U10.3, U10.4; also elsewhere on the board
unnamed: D1.2 (A), D3.2 (A), R10.2
unnamed: D1.1 (K), U1.6 (~STDBY)
unnamed: C47.1, D2.1 (K), Q1.2 (S), Q2.2 (S), R4.2, U8.6 (VDD)
unnamed: D3.1 (K), U1.7 (~CHRG)
unnamed: D4.2 (A), R12.2
unnamed: D6.1 (K), R4.1, SW1.4, U8.1 (KEY)
unnamed: Q2.1 (G), U8.4 (OUTL)
unnamed: R18.1, R19.2
unnamed: C2.1, R9.2, R10.1, U1.4 (V_{CC}), U1.8 (CE)
unnamed: R13.1, R14.2, U1.2 (PROG)
unnamed: R32.1, U2.8 (EN2), U2.9 (EN1), U2.18 (EN3)
unnamed: C10.2, R20.1, R21.2, U2.14 (FB1)
unnamed: C7.2, R15.2, R16.2, U2.3 (FB2)
unnamed: C8.2, R17.1, R18.2, U2.2 (FB3)
unnamed: L3.1, U2.11 (LX1)
unnamed: L1.1, U2.6 (LX2)
unnamed: L2.1, U2.20 (LX3)
VBAT: C1.1, Q1.3 (D), TP12.1, U1.5 (BAT), U10.1
VBAT_OUT: C3.1, C4.1, C5.1, C6.1, C48.1, Q2.3 (D), R32.2, U2.7 (VIN2), U2.10 (VIN1), U2.16 (VCC), U2.19 (VIN3); also elsewhere on the board
VBUS: D2.2 (A), Q1.1 (G), R9.1, R11.2, TP11.1; also elsewhere on the board

Notes on the sheet:
按键开关机（低压保护也靠这个切断） 感谢群友：“你说得对”、**星语Studio** 、土豆、量子！
SH1.0端子
电池规格书要求充电电流：0.2C 300mA Rchrg=3.38k Ichrg=296mA

Parts:
C32, C34: 100nF; C_0603_1608Metric
C33: 10uF; C_0603_1608Metric
C35: 1uF; C_0603_1608Metric
C36: 100nF; C_0603_1608Metric; not fitted
D5: 1N5819WS; D_SOD-323
L4: FTC252012S1R5MBCA; IND-SMD_L2.5-W2.0-VLS252012CX-150M
R7, R41, R42: 10K; R_0603_1608Metric; not fitted
R27, R28, R29: 10K; R_0603_1608Metric
R30: 10R; R_0603_1608Metric
U4: 3寸液晶屏TFT 全新无定义资料; Hirose_FH12-40S-0.5SH_1x40-1MP_P0.50mm_Horizontal
U5: ST7701 IPS; FPC-SMD_40P-P0.50_HC-FPC-0.5-40P-CSH20; not fitted
U9: STI9287C; SOT-23-6_L2.9-W1.6-P0.95-LS2.8-BL; LCSC Part C2985059

Connections:
+3.3V: C32.1, R28.2, R29.2, R42.2, U4.4 (VDD), U5.3 (VCI), U5.39 (IM1); also elsewhere on the board
/screen/SCREEN_B0: U4.24 (B0), U5.29 (R0); also elsewhere on the board
/screen/SCREEN_B1: U4.25 (B1), U5.30 (R1); also elsewhere on the board
/screen/SCREEN_B2: U4.26 (B2), U5.31 (R2); also elsewhere on the board
/screen/SCREEN_B3: U4.27 (B3), U5.32 (R3); also elsewhere on the board
/screen/SCREEN_B4: U4.28 (B4), U5.33 (R4); also elsewhere on the board
/screen/SCREEN_BL_CTRL: R7.1, R28.1, U9.4 (EN/PWM); also elsewhere on the board
/screen/SCREEN_CS: U4.39 (CS), U5.35 (CS); also elsewhere on the board
/screen/SCREEN_G0: U4.15 (G0), U5.23 (G0); also elsewhere on the board
/screen/SCREEN_G1: U4.16 (G1), U5.24 (G1); also elsewhere on the board
/screen/SCREEN_G2: U4.17 (G2), U5.25 (G2); also elsewhere on the board
/screen/SCREEN_G3: U4.18 (G3), U5.26 (G3); also elsewhere on the board
/screen/SCREEN_G4: U4.19 (G4), U5.27 (G4); also elsewhere on the board
/screen/SCREEN_G5: U4.20 (G5), U5.28 (G5); also elsewhere on the board
/screen/SCREEN_HS: U4.32 (HSYNC), U5.15 (HS); also elsewhere on the board
/screen/SCREEN_LED_A: C35.1, D5.1 (K), U4.2 (LEDA), U5.1 (LEDA), U9.5 (OVP)
/screen/SCREEN_LED_K: R30.2, U4.1 (LEDK), U5.2 (LEDK), U9.3 (FB)
/screen/SCREEN_PCLK: U4.30 (PCLK), U5.16 (PCLK); also elsewhere on the board
/screen/SCREEN_R0: U4.8 (R0), U5.18 (B0); also elsewhere on the board
/screen/SCREEN_R1: U4.9 (R1), U5.19 (B1); also elsewhere on the board
/screen/SCREEN_R2: U4.10 (R2), U5.20 (B2); also elsewhere on the board
/screen/SCREEN_R3: U4.11 (R3), U5.21 (B3); also elsewhere on the board
/screen/SCREEN_R4: U4.12 (R4), U5.22 (B4); also elsewhere on the board
/screen/SCREEN_SCL: U4.37 (SCL), U5.36 (SCL); also elsewhere on the board
/screen/SCREEN_SDA: U4.38 (SDA), U5.37 (SDA); also elsewhere on the board
/screen/SCREEN_VS: U4.33 (VSYNC), U5.14 (VS); also elsewhere on the board
GND: C32.2, C33.2, C34.2, C35.2, C36.2, R7.2, R27.2, R30.1, R41.2, U4.3 (GND), U4.29 (GND), U4.36 (GND), U4.MP, U5.4 (GND), U5.5 (D0N), U5.6 (D0P), U5.7 (GND), U5.8 (CLKN), U5.9 (CLKP), U5.10 (GND), U5.11 (D1N), U5.12 (D1P), U5.13 (GND), U5.38 (IM0), U5.40 (IM2), U5.MP, U9.2 (GND); also elsewhere on the board
unnamed: D5.2 (A), L4.2, U9.1 (SW)
unnamed: R27.1, U4.34 (DE)
unnamed: C34.1, R29.1, U4.40 (RESET)
unnamed: R41.1, U5.17 (DEN)
unnamed: C36.1, R42.1, U5.34 (RESET)
VBAT_OUT: C33.1, L4.1, U9.6 (IN); also elsewhere on the board

Notes on the sheet:
*4/*5:开机默认背光状态 贴R28: 默认开背光 贴R7：默认关背光 手动复刻建议贴R28 调试结束后贴R7 批量直接R7+QC
RSense = 0.2 / I_LED = 10 Ohm
通用ST7701 RGB+MIPI屏幕接口 上接！！ 已测试型号： XH3.0TFT-40P360X640 CY300H4003 背光：6串12V20mA
EN Dimming with wide PWM Frequency Range: 1kHz to 200kHz
50V耐压！
Alt.BOM:SY7200A
SWAP color in F1C TCON
U4 R27 R29 C34 U5 R41 R42 R36 说明： 若购买的屏幕是老王电子的3元屏，只贴装U4 R27 R29 C34 若购买的屏幕是通用的ST7701 3寸钢壳屏，只贴装U5 R41 R42 C36
老王电子的3元TFT 下接！！ （已断货） 此款背光为4串12V20mA

Board: 4 copper layers, 50.0 x 100.0 mm, 150 parts (0 on the bottom side), 107 nets.

## Commit log

2025-11-18 inital commit with version 0.2
2025-11-29 change hole size in QFN EP for a better solder flow.
2025-12-06 Change file structure
    [/] 大改文件结构，使其更加简介易用
    [/] 整合文件，使仓库更整齐
    [+] 增加手册，利于新手入门(还在写）
2025-12-06 fix docs
2025-12-10 diy tutorial #1
2025-12-12 ADD Manuel
    add V0.3FAQ
2025-12-12 Fix image links
    Updated FAQ.md with new image links and troubleshooting steps.
2025-12-14 Enhance README with specifications and project details
    Updated the README to include detailed specifications and features of the 明日方舟电子通行证 (DevKit version).
2025-12-31 Update version
2026-01-01 0.5.1 4 layer.
2026-01-03 V1.0 or 4L final i hope
2026-01-20 Add note about downloading立创EDA version 0.6
2026-02-01 JLC 0.6.

Notices in the files:
electric_pass_baseboard.kicad_pcb:
Pharmaceutical Inc., all rights reserved.
